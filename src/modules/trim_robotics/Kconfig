## src/modules/trim_robotics/Kconfig
```kconfig
menuconfig MODULES_TRIM_ROBOTICS
	bool "trim_robotics"
	default y
	---help---
		Enable support for Trim Robotics' module
```
